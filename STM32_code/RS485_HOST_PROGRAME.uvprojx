# Keil uVision project RS485_HOST_PROGRAME.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS485_HOST_PROGRAME +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\STM32F10x_FWLib\inc;.\HARDWARE\CRC16;.\HARDWARE\RS485;.\HARDWARE\TIMER;.\HARDWARE\LED;.\HARDWARE\KEY;.\DEMO;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ../../../../4-1 OLED显示屏/Start/: stm32f10x.h
  group HAREWARD
    ./HARDWARE/LED/: led.c
    ./HARDWARE/RS485/: rs485.c
    ./HARDWARE/CRC16/: crc16.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/oled/: OLED.c
    ./HARDWARE/: OLED_Font.h OLED.h
    ./HAREWARD/: Serial.h Serial.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group CODE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ./STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group Demo
    ./DEMO/: demo.c
